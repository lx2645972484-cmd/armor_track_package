Commit message: 完成旋转中心更新

File: install/armor_urdf/share/armor_urdf/urdf/armor_urdf.urdf (robot description, URDF)
Before this commit: robot turret_with_camera_imu, 5 links, 4 joints
Joints:
- joint yaw_joint: origin xyz=0.0 0.0 0.03 rpy=0 0 0 -> xyz=0.0 0.0 0.02 rpy=0 0 0
